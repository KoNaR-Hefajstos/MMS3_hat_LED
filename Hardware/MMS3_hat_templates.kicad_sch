File: Hardware/MMS3_hat_templates.kicad_sch (KiCad schematic)
At the start: 12 parts, among them U1 AMS1117

Commit message: updated readme
Connections:
- no-connect marks 5 -> 7
